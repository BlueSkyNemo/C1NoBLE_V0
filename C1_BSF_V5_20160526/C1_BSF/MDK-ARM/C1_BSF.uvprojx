# Keil uVision project C1_BSF.uvprojx, settings and files
target C1_BSF Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: C1 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c misc: --C99
  c include: ../Inc;         D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Inc;         D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;         D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Include;         D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: dma.c usart.c stm32f0xx_it.c main.c stm32f0xx_hal_msp.c gpio.c tim.c Button.c Console.c DelayCall.c FPE.c IAP.c Thread.c Tick.c lcd.c wwdg.c
  group Application/MDK-ARM
    D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group Drivers/CMSIS
    D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    D:/Users/TF/STM32Cube/Repository/STM32Cube_FW_F0_V1.4.0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_wwdg.c
software components: CMSIS:CORE 4.1.0
